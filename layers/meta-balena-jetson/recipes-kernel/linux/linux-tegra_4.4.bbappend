inherit kernel-resin

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " \
	file://0003-m_ttcan.c-Rename-to-m_ttcan_ext.c.patch \
	"

BALENA_CONFIGS_append = " uvc"

BALENA_CONFIGS[uvc] = " \
		CONFIG_USB_VIDEO_CLASS=m \
		CONFIG_USB_VIDEO_CLASS_INPUT_EVDEV=y \
		"

BALENA_CONFIGS_DEPS[uvc] = " \
		CONFIG_MEDIA_CAMERA_SUPPORT=y \
		CONFIG_VIDEO_V4L2_SUBDEV_API=y \
		CONFIG_VIDEO_V4L2=m \
		CONFIG_VIDEOBUF2_CORE=m \
		CONFIG_VIDEOBUF2_MEMOPS=m \
		CONFIG_VIDEOBUF2_VMALLOC=m \
		CONFIG_MEDIA_USB_SUPPORT=y \
		CONFIG_USB_GSPCA=m \
		CONFIG_SND_USB=y \
		CONFIG_SND_USB_AUDIO=m \
		"

BALENA_CONFIGS_append = " egalax"

BALENA_CONFIGS[egalax] = " \
		CONFIG_TOUCHSCREEN_EGALAX=m \
		"

BALENA_CONFIGS_append = " serial"
BALENA_CONFIGS[serial] = " \
		CONFIG_USB_SERIAL_GENERIC=y \
		"
